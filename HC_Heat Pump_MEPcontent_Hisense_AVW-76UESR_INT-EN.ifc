Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-02-06T09:26:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 06 09:26:56 2018 * Host: B3ROBRAWR3858 * Database: C:\Users\DD\AppData\Local\Temp\{A5B8158A-E14C-4F8B-8F76-A2EDF9BB760D}\ifc * Database version: 5507 * Database creation date: Tue Feb 06 09:26:54 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Feb 06 09:26:54 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 06 09:26:54 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcPump: AVW-76UESR, HC_Heat Pump_MEPcontent_Hisense_AVW76UESR-114UESR_INT-EN:AVW-76UESR:1315057
In: V00
Type - Material: Color RGB 024-077-198, Color RGB 216-216-216, Color RGB 000-204-204
Type - Dimensions - Depth: 390 mm; Drain Diameter: 32 mm; Height: 1650 mm; Refrigerant Gas Diameter: 19 mm; Refrigerant Liquid Diameter: 9.53 mm; Width: 1100 mm
Type - Electrical - ELB Nominal Current: 30 A; Hertz: 50 Hz; Maximum Running Current: 20.5 A; Phase: 3; Voltage: 400 V
Type - Identity Data - Article Description: Heat pump outdoor unit; Article Type: AVW-76UESR; Content Supplier URL: www.mepcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Heat pump outdoor unit; EMCS Version: 3.0; ETIM Article Class: EC001213; Family Version: 11.12; Manufacturer: Hisense; Manufacturer Art. No.: AVW-76UESR; Manufacturer URL: http://www.hs-cs.nl/; MEPcontent Class: HEATPUMP; Model: AVW-76UESR; OmniClass Number: 23.75.10.21; OmniClass Title: Heat Pumps; Product Line: Hi-Flexi C series; Revit Version: 2016; Type Name: AVW-76UESR; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Blue: Color RGB 024-077-198; Grey: Color RGB 080-080-080; Logo: Color RGB 000-204-204; White: Color RGB 216-216-216
Type - Mechanical - Loads - Airflow Rate (m3/min): 121; Compressor Motor Output (kW): 4.8; Cooling Capacity (kW): 22.4; Cooling EER (kW/kW): 3.45; Cooling Power Input (kW): 3.25; Cooling Sound Pressure Level (dB(A)): 53; External Static Pressure (Pa): 0; Fan Motor Output (kW): 0.29; Heating Capacity (kW): 25; Heating COP (kW/kW): 3.75; Heating Power Input (kW): 3.33; Heating Sound Pressure Level (dB(A)): 53; Unit Weight (kg): 93
Type - Other - Category: Mechanical Equipment; Compressor Quantity: 1; Compressor Type: E656DHD; Family Name: HC_Heat Pump_MEPcontent_Hisense_AVW76UESR-114UESR_INT-EN; Fan Quantity: 2; Fan Type: Propeller Fan; Indoor Unit Total Capacity: 50 to 130% of outdoor unit capacity; Refrigerant Charge (kg): 3.6; Refrigerant Type: R410A
Pset_ManufacturerTypeInformation - Manufacturer: Hisense
Constraints - Offset: 0 mm
Dimensions - Area: 9.67901 m2; Volume: 3.44399 m3
Electrical - Loads - Power: 0 W
Identity Data - Mark: 4
Mechanical - Drain Fixture Units: 0; Refrigerant Gas Flow: 0 m3/s; Refrigerant Liquid Flow: 0 m3/s; System Classification: Sanitary,Power,Undefined
Other - Back Clearance Safe: 300 mm; Family: HC_Heat Pump_MEPcontent_Hisense_AVW76UESR-114UESR_INT-EN: AVW-76UESR; Family and Type: HC_Heat Pump_MEPcontent_Hisense_AVW76UESR-114UESR_INT-EN: AVW-76UESR; Front Clearance Safe: 600 mm; Gas Connector Angle: 0 deg; Gas Connector Length: 80.5 mm; Left Clearance Safe: 50 mm; Liquid Connector Angle: 0 deg; Liquid Connector Length: 30.5 mm; Right Clearance Safe: 100 mm; Type: HC_Heat Pump_MEPcontent_Hisense_AVW76UESR-114UESR_INT-EN: AVW-76UESR; Type Id: HC_Heat Pump_MEPcontent_Hisense_AVW76UESR-114UESR_INT-EN: AVW-76UESR
Phasing - Phase Created: 4. Plan over 10 jaar
Visibility - Back Clearance: 300 mm; Front Clearance: 600 mm; Front Connection: yes; Left Clearance: 50 mm; Rear Connection: no; Right Clearance: 100 mm; Right Connection: no; Service Space: no
